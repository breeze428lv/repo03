# Keil uVision project STM32-DEMO.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: CPWS +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\FWLIB\inc;..\FWLIB\src;..\USER;..\HMI;..\PUBLIC;..\APP\adc;..\APP\dac;..\APP\relays;..\APP\timing;..\API_COMM;..\APP\uart;..\APP\stm32_flash
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTCODE
    ../CMSIS/startup/: startup_stm32f10x_md.s
  group USER
    ./: main.c manual_control.c settings.c time_control.c measurement.c security.c ui_controls.c UserInterface.c pump_running.c pump_sleeping.c error_handle.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group HMI
    ../HMI/: cmd_queue.c hmi_driver.c hmi_user_uart.c
  group PUBLIC
    ../PUBLIC/: system.c SysTick.c stm32f10x_it.c ulitity.c hw_config.c
  group APP
    ../APP/adc/: adc.c
    ../APP/dac/: DAC.C
    ../APP/timing/: delay.c
    ../APP/uart/: usart.c
    ../APP/stm32_flash/: stm32_flash.c
    ../APP/relays/: relays.C
  group API_COMM
    ../API_COMM/: api_comm.c
